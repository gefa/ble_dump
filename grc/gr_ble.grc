options:
  parameters:
    generate_options: no_gui
    id: gr_ble
    output_language: python
    title: ble_receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: int(2402e6)
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: (ble_base_freq+(ble_channel_spacing*ble_channel))
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: gmsk_gain_mu
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: gmsk_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gmsk_omega_limit
  id: variable
  parameters:
    value: '0.035'
  states: {}
- name: gmsk_sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, sample_rate, cutoff_freq, transition_width, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-80'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: '-70'
  states: {state: disabled}
- name: analog_simple_squelch_cc_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: squelch_threshold
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: digital_correlate_access_code_bb_0
  id: digital_correlate_access_code_bb
  parameters:
    access_code: '101010'
    threshold: ''
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '10001110100010011011111011010110'
    tagname: packet
    threshold: '1'
    type: byte
  states: {state: disabled}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: gmsk_gain_mu
    mu: gmsk_mu
    omega_relative_limit: gmsk_omega_limit
    samples_per_symbol: gmsk_sps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      BLE_PREAMBLE = '\xAA'
      bin8 = lambda x : ''.join(reversed( [str((x >> i) & 1) for i in range(8)] ) )
      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              gr_buffer = ""
              if self.example_param == 1:
                  print(input_items)
              for i in input_items[0]:
                  gr_buffer = gr_buffer + chr(i) #str(bin(i))[2:]
              if self.example_param == 1:
                  print(gr_buffer)
              self.example_param = 0
              for pos in [position for position, byte, in enumerate(gr_buffer) if byte == BLE_PREAMBLE]:
                  print("pos {} byte {%02x}".format(pos,byte))
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 1e6
    decim: '1'
    samp_rate: sample_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq-freq_offset
    dc_offs_enb0: 'True'
    dev_args: '""'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: sample_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', digital_gmsk_demod_0, '0']
- [analog_simple_squelch_cc_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_unpacked_to_packed_xx_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', epy_block_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', zeromq_push_sink_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [digital_gmsk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_null_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', digital_gmsk_demod_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', analog_simple_squelch_cc_1, '0']

metadata:
  file_format: 1
